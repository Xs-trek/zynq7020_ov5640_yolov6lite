FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://cam_ov5640_control.cfg"
